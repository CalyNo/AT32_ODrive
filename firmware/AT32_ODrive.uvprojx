# Keil uVision project AT32_ODrive.uvprojx, settings and files
target AT32_ODrive (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F435CGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.8
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: AT32_ODrive +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F435CGT7,HEXT_VALUE=8000000
  c misc: --diag_suppress=188
  c include: .\Inc;.\Config;.\Drivers\CMSIS\Core\Include;.\Drivers\CMSIS\Device\AT32F435_437;.\Drivers\AT32F435_437_Firmware_Library\inc;.\Drivers\USB_Device\inc
  asm misc: --diag_suppress=188
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0xfe000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group User
    ./Src/: main.c app.c scheduler.c system_time.c util.c crc.c board.c pwm.c adc.c encoder.c encoder_pll.c foc.c pid.c traptraj.c calibration.c controller.c axis.c param.c can_comm.c uart_comm.c nvm_config.c led_pattern.c status_led.c usb_cdc.c usb_fibre.c fibre_server.c fibre_endpoints.c ws2812.c
  group Startup
    ./Startup/: startup_at32f435_437_mdk.s
  group CMSIS
    ./Drivers/CMSIS/Device/AT32F435_437/: system_at32f435_437.c
  group AT32 Drivers
    ./Drivers/AT32F435_437_Firmware_Library/src/: at32f435_437_crm.c at32f435_437_gpio.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_flash.c at32f435_437_tmr.c at32f435_437_adc.c at32f435_437_spi.c at32f435_437_usart.c at32f435_437_can.c at32f435_437_dma.c at32f435_437_exint.c at32f435_437_debug.c at32f435_437_wdt.c at32f435_437_usb.c
  group USB Device
    ./Drivers/USB_Device/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c cdc_class.c cdc_desc.c
  group Config
    ./Config/: at32f435_437_conf.h usb_conf.h
    ./Inc/: config.h board.h nvm_config.h
